/dts-v1/;
/ {
        compatible = "amd,versal2-vmk365-revA", "amd,versal2-vmk365", "amd,versal2";
        model = "AMD Versal VMK365 revA";
        #address-cells = <0x2>;
        #size-cells = <0x2>;
        interrupt-parent = <&gic_r52>;
        board = "vmk365";
        vivado-version = "2026.2";
        device_id = "xc2vm3654";
        xlnx,ddrmc5-debug-elf = "false";
        xlnx,ddrmc5-i2c-master = "PMC";
        variant = "Versal_2VE_2VM_Small";
        slrcount = <0x1>;
        family = "Versal_2VE_2VM";
        speed_grade = "2MP";
        pruned-sdt = <0x1>;

        options {

                u-boot {
                        compatible = "u-boot,config";
                        bootscr-address = /bits/ 64 <0x78000000>;
                };
        };

        cpu_opp_table: opp-table {
                phandle = <0xf9>;
                compatible = "operating-points-v2";

                opp-1867000000 {
                        opp-hz = /bits/ 64 <0x6f4828c0>;
                        clock-latency-ns = <0x7a120>;
                        opp-microvolt = <0xf4240>;
                };

                opp-933500000 {
                        opp-hz = /bits/ 64 <0x37a41460>;
                        clock-latency-ns = <0x7a120>;
                        opp-microvolt = <0xf4240>;
                };

                opp-622333333 {
                        opp-hz = /bits/ 64 <0x25180d95>;
                        clock-latency-ns = <0x7a120>;
                        opp-microvolt = <0xf4240>;
                };

                opp-466750000 {
                        opp-hz = /bits/ 64 <0x1bd20a30>;
                        clock-latency-ns = <0x7a120>;
                        opp-microvolt = <0xf4240>;
                };
        };

        cpus_r52_1: cpus-r52@1 {
                phandle = <0xfb>;
                #address-cells = <0x1>;
                #size-cells = <0x0>;
                compatible = "cpus,cluster";
                address-map = <0xf0000000 &amba 0xf0000000 0x10000000>,
                 <0xf9000000 &amba_rpu 0xf9000000 0x3000>,
                 <0x9968000 &NoC_C0_C1_ddr_memory 0x9968000 0x60000>,
                 <0xeb350000 &ipi2 0xeb350000 0x10000>,
                 <0xf1920000 &serial0 0xf1920000 0x10000>,
                 <0xf1940000 &i2c0 0xf1940000 0x10000>,
                 <0xf1e90000 &ttc3 0xf1e90000 0x10000>,
                 <0xe2000000 &gic_r52 0xe2000000 0x10000>;
                #ranges-address-cells = <0x1>;
                #ranges-size-cells = <0x1>;

                cpu-map {

                        cluster0 {

                                core0 {
                                        cpu = <&cortexr52_1>;
                                };
                        };
                };

                cortexr52_1: cpu@0 {
                        phandle = <0xbb>;
                        compatible = "arm,cortex-r52";
                        device_type = "cpu";
                        reg = <0x0>;
                        power-domains = <&scmi_devpd 0x1>;
                        xlnx,is-cache-coherent = <0x0>;
                        xlnx,timestamp-clk-freq = <0x5f5dd19>;
                        xlnx,pss-ref-clk-freq = <0x1fc9f08>;
                        xlnx,ip-name = "cortexr52";
                        xlnx,cluster-number = <0x0>;
                        cpu-frequency = <0x34274ea8>;
                        bus-handle = <0x2>;
                        xlnx,cpu-clk-freq-hz = <0x34274ea8>;
                };
        };

        aliases {
                serial0 = "/axi/serial@f1920000";
                i2c1 = "/axi/i2c@f1940000";
        };

        firmware {

                psci: psci {
                        phandle = <0x104>;
                        compatible = "arm,psci-1.0";
                        method = "smc";
                };

                scmi: scmi {
                        phandle = <0x105>;
                        compatible = "arm,scmi-smc";
                        arm,smc-id = <0xc2002001>;
                        #address-cells = <0x1>;
                        #size-cells = <0x0>;
                        shmem = <0xda>;
                        bootph-all;

                        scmi_reset: protocol@16 {
                                phandle = <0xe1>;
                                reg = <0x16>;
                                #reset-cells = <0x1>;
                        };

                        scmi_devpd: protocol@11 {
                                phandle = <0xb9>;
                                reg = <0x11>;
                                #power-domain-cells = <0x1>;
                        };

                        scmi_clk: protocol@14 {
                                phandle = <0xae>;
                                reg = <0x14>;
                                #clock-cells = <0x1>;
                        };
                };

                versal2_firmware: versal2-firmware {
                        phandle = <0x106>;
                        compatible = "xlnx,versal2-firmware";
                        bootph-all;
                        method = "smc";
                        #power-domain-cells = <0x1>;

                        versal_sec_cfg: versal-sec-cfg {
                                phandle = <0x107>;
                                compatible = "xlnx,versal-sec-cfg";

                                nvmem-layout {
                                        compatible = "fixed-layout";
                                        #address-cells = <0x1>;
                                        #size-cells = <0x1>;

                                        bbram_zeroize: bbram-zeroize@4 {
                                                phandle = <0x108>;
                                                reg = <0x4 0x4>;
                                        };

                                        bbram_key: bbram-key@10 {
                                                phandle = <0x109>;
                                                reg = <0x10 0x20>;
                                        };

                                        bbram_usr: bbram-usr@30 {
                                                phandle = <0x10a>;
                                                reg = <0x30 0x4>;
                                        };

                                        bbram_lock: bbram-lock@48 {
                                                phandle = <0x10b>;
                                                reg = <0x48 0x4>;
                                        };

                                        user_key0: user-key@110 {
                                                phandle = <0x10c>;
                                                reg = <0x110 0x20>;
                                        };

                                        user_key1: user-key@130 {
                                                phandle = <0x10d>;
                                                reg = <0x130 0x20>;
                                        };

                                        user_key2: user-key@150 {
                                                phandle = <0x10e>;
                                                reg = <0x150 0x20>;
                                        };

                                        user_key3: user-key@170 {
                                                phandle = <0x10f>;
                                                reg = <0x170 0x20>;
                                        };

                                        user_key4: user-key@190 {
                                                phandle = <0x110>;
                                                reg = <0x190 0x20>;
                                        };

                                        user_key5: user-key@1b0 {
                                                phandle = <0x111>;
                                                reg = <0x1b0 0x20>;
                                        };

                                        user_key6: user-key@1d0 {
                                                phandle = <0x112>;
                                                reg = <0x1d0 0x20>;
                                        };

                                        user_key7: user-key@1f0 {
                                                phandle = <0x113>;
                                                reg = <0x1f0 0x20>;
                                        };
                                };
                        };
                };
        };

        fpga: fpga-region {
                phandle = <0x114>;
                compatible = "fpga-region";
                fpga-mgr = <&versal_fpga>;
                #address-cells = <0x2>;
                #size-cells = <0x2>;
        };

        timer: timer {
                phandle = <0x115>;
                compatible = "arm,armv8-timer";
                interrupts = <0x1 0xd 0x4 0x1 0xe 0x4 0x1 0xb 0x4 0x1 0xa 0x4>;
        };

        versal_fpga: versal-fpga {
                phandle = <0xdb>;
                compatible = "xlnx,versal-fpga";
        };

        amba_apu: apu-bus {
                phandle = <0x3>;
                compatible = "simple-bus";
                #address-cells = <0x2>;
                #size-cells = <0x2>;
                ranges;
                u-boot,dm-pre-reloc;
        };

        amba_rpu: rpu-bus {
                phandle = <0xb3>;
                compatible = "indirect-bus";
                #address-cells = <0x2>;
                #size-cells = <0x2>;
                ranges;
                interrupt-parent = <&gic_r52>;
                u-boot,dm-pre-reloc;

                gic_r52: interrupt-controller@e2000000 {
                        phandle = <0xb6>;
                        compatible = "arm,gic-v3", "arm,gic";
                        #interrupt-cells = <0x3>;
                        interrupt-controller;
                        interrupt-parent = <&gic_r52>;
                        interrupts = <0x1 0x9 0x4>;
                        #address-cells = <0x2>;
                        #size-cells = <0x2>;
                        reg = <0x0 0xe2000000 0x0 0x10000 0x0 0xe2100000 0x0 0x80000>;
                        status = "okay";
                        xlnx,ip-name = "rcpu_gic";
                        xlnx,name = "ps_wizard_0_ps11_0_rcpu_gic";
                };
        };

        sensor0: versal-thermal-sensor {
                phandle = <0xdc>;
                compatible = "xlnx,versal-thermal";
                #thermal-sensor-cells = <0x1>;
                io-channel-names = "sysmon-temp-channel";
        };

        thermal-zones {

                versal_thermal: versal-thermal {
                        phandle = <0x118>;
                        polling-delay-passive = <0xfa>;
                        polling-delay = <0x3e8>;
                        thermal-sensors = <&sensor0 0x0>;

                        trips {

                                temp_alert: temp-alert {
                                        phandle = <0x119>;
                                        temperature = <0x11170>;
                                        hysteresis = <0x0>;
                                        type = "passive";
                                };

                                ot_crit: ot-crit {
                                        phandle = <0x11a>;
                                        temperature = <0x1e848>;
                                        hysteresis = <0x0>;
                                        type = "critical";
                                };
                        };

                        cooling-maps {
                        };
                };

                versal_thermal_aie: versal-aie-thermal {
                        phandle = <0x11b>;
                        polling-delay-passive = <0xfa>;
                        polling-delay = <0x3e8>;
                        thermal-sensors = <&sensor0 0x1>;

                        trips {

                                temp_alert_aie: temp-alert-aie {
                                        phandle = <0x11c>;
                                        temperature = <0x11170>;
                                        hysteresis = <0x0>;
                                        type = "passive";
                                };

                                ot_crit_aie: ot-crit-aie {
                                        phandle = <0x11d>;
                                        temperature = <0x1e848>;
                                        hysteresis = <0x0>;
                                        type = "critical";
                                };
                        };

                        cooling-maps {
                        };
                };
        };

        amba: axi {
                phandle = <0x2>;
                compatible = "simple-bus";
                bootph-all;
                #address-cells = <0x2>;
                #size-cells = <0x2>;
                ranges;
                interrupt-parent = <&gic_r52>;

                i2c0: i2c@f1940000 {
                        phandle = <0x95>;
                        compatible = "cdns,i2c-r1p14";
                        status = "okay";
                        reg = <0x0 0xf1940000 0x0 0x1000>;
                        interrupt-parent = <&gic_r52>;
                        interrupts = <0x0 0x15 0x4>;
                        clocks = <&scmi_clk 0x47>;
                        power-domains = <&scmi_devpd 0xf>;
                        xlnx,clock-freq = <0x98961be>;
                        xlnx,i2c-clk-freq-hz = <0x98961be>;
                        xlnx,ip-name = "i2c";
                        xlnx,iic-board-interface = "custom";
                        xlnx,name = "ps_wizard_0_ps11_0_i2c_0";
                };

                serial0: serial@f1920000 {
                        phandle = <0x93>;
                        bootph-all;
                        compatible = "arm,pl011", "arm,primecell";
                        status = "okay";
                        reg = <0x0 0xf1920000 0x0 0x1000>;
                        interrupt-parent = <&gic_r52>;
                        interrupts = <0x0 0x19 0x4>;
                        reg-io-width = <0x4>;
                        clock-names = "uartclk", "apb_pclk";
                        clocks = <&scmi_clk 0x3a>,
                         <&scmi_clk 0x34>;
                        power-domains = <&scmi_devpd 0x13>;
                        device_type = "serial";
                        xlnx,clock-freq = <0x5f5dd19>;
                        xlnx,uart-board-interface = "custom";
                        xlnx,has-modem = <0x0>;
                        xlnx,ip-name = "sbsauart";
                        xlnx,baudrate = <0x1c200>;
                        cts-override;
                        port-number = <0x0>;
                        xlnx,uart-clk-freq-hz = <0x5f5dd19>;
                        xlnx,name = "ps_wizard_0_ps11_0_sbsauart_0";
                };

                ttc3: timer@f1e90000 {
                        phandle = <0x9f>;
                        compatible = "cdns,ttc";
                        status = "okay";
                        interrupt-parent = <&gic_r52>;
                        interrupts = <0x0 0x2e 0x4 0x0 0x2e 0x4 0x0 0x2e 0x4>;
                        timer-width = <0x20>;
                        reg = <0x0 0xf1e90000 0x0 0x1000>;
                        clocks = <&scmi_clk 0x14>;
                        power-domains = <&scmi_devpd 0x19>;
                        xlnx,ttc-board-interface = "custom";
                        xlnx,ttc-clk2-freq-hz = <0x8f0cba9>;
                        xlnx,ttc-clk1-clksrc = "APB";
                        xlnx,clock-freq = <0x8f0cba9>;
                        xlnx,ttc-clk2-clksrc = "APB";
                        xlnx,ip-name = "ttc";
                        xlnx,ttc-clk0-freq-hz = <0x8f0cba9>;
                        xlnx,ttc-clk1-freq-hz = <0x8f0cba9>;
                        xlnx,ttc-clk0-clksrc = "APB";
                        xlnx,name = "ps_wizard_0_ps11_0_ttc_3";
                };

                ipi2: mailbox@eb350000 {
                        phandle = <0xba>;
                        status = "okay";
                        compatible = "xlnx,versal-ipi-mailbox";
                        interrupt-parent = <&gic_r52>;
                        interrupts = <0x0 0x3b 0x4>;
                        reg = <0x0 0xeb350000 0x0 0x10000 0x0 0xeb3f0800 0x0 0x200>;
                        xlnx,ipi-bitmask = <0x10>;
                        xlnx,ipi-id = <0x4>;
                        xlnx,ipi-buf-index = <0x4>;
                        #address-cells = <0x2>;
                        #size-cells = <0x2>;
                        ranges;
                        xlnx,cpu-name = "R52_1";
                        xlnx,buffer-base = <0xeb3f0800>;
                        xlnx,buffer-index = <0x4>;
                        xlnx,ip-name = "ipi";
                        xlnx,ipi-target-count = <0xc>;
                        reg-names = "ctrl", "msg";
                        xlnx,int-id = <0x5b>;
                        xlnx,bit-position = <0x4>;
                        xlnx,name = "ps_wizard_0_ps11_0_ipi_2";

                        ipi_2_to_ipi_asu: child@eb310000 {
                                phandle = <0x169>;
                                compatible = "xlnx,versal-ipi-dest-mailbox";
                                xlnx,ipi-bitmask = <0x1>;
                                xlnx,cpu-name = "ASU";
                                xlnx,ipi-rsp-msg-buf = <0xeb3f0820>;
                                #mbox-cells = <0x1>;
                                xlnx,ipi-id = <0x0>;
                                reg = <0x0 0xeb310000 0x0 0x10000 0x0 0xeb3f0000 0x0 0x200>;
                                xlnx,ipi-buf-index = <0x0>;
                                xlnx,ipi-req-msg-buf = <0xeb3f0800>;
                                reg-names = "ctrl", "msg";
                        };

                        ipi_2_to_ipi_0: child@eb330000 {
                                phandle = <0x16a>;
                                compatible = "xlnx,versal-ipi-dest-mailbox";
                                xlnx,ipi-bitmask = <0x4>;
                                xlnx,cpu-name = "A78_0";
                                xlnx,ipi-rsp-msg-buf = <0xeb3f08a0>;
                                #mbox-cells = <0x1>;
                                xlnx,ipi-id = <0x2>;
                                reg = <0x0 0xeb330000 0x0 0x10000 0x0 0xeb3f0400 0x0 0x200>;
                                xlnx,ipi-buf-index = <0x2>;
                                xlnx,ipi-req-msg-buf = <0xeb3f0880>;
                                reg-names = "ctrl", "msg";
                        };

                        ipi_2_to_ipi_1: child@eb340000 {
                                phandle = <0x16b>;
                                compatible = "xlnx,versal-ipi-dest-mailbox";
                                xlnx,ipi-bitmask = <0x8>;
                                xlnx,cpu-name = "R52_0";
                                xlnx,ipi-rsp-msg-buf = <0xeb3f08e0>;
                                #mbox-cells = <0x1>;
                                xlnx,ipi-id = <0x3>;
                                reg = <0x0 0xeb340000 0x0 0x10000 0x0 0xeb3f0600 0x0 0x200>;
                                xlnx,ipi-buf-index = <0x3>;
                                xlnx,ipi-req-msg-buf = <0xeb3f08c0>;
                                reg-names = "ctrl", "msg";
                        };

                        ipi_2_to_ipi_1_nobuf: child@eb3b0000 {
                                phandle = <0x16c>;
                                compatible = "xlnx,versal-ipi-dest-mailbox";
                                xlnx,ipi-bitmask = <0x400>;
                                xlnx,cpu-name = "A78_0";
                                #mbox-cells = <0x1>;
                                xlnx,ipi-id = <0xa>;
                                reg = <0x0 0xeb3b0000 0x0 0x1000>;
                                xlnx,ipi-buf-index = <0xffff>;
                                reg-names = "ctrl";
                        };

                        ipi_2_to_ipi_2: child@eb350000 {
                                phandle = <0x16d>;
                                compatible = "xlnx,versal-ipi-dest-mailbox";
                                xlnx,ipi-bitmask = <0x10>;
                                xlnx,cpu-name = "R52_1";
                                xlnx,ipi-rsp-msg-buf = <0xeb3f0920>;
                                #mbox-cells = <0x1>;
                                xlnx,ipi-id = <0x4>;
                                reg = <0x0 0xeb350000 0x0 0x10000 0x0 0xeb3f0800 0x0 0x200>;
                                xlnx,ipi-buf-index = <0x4>;
                                xlnx,ipi-req-msg-buf = <0xeb3f0900>;
                                reg-names = "ctrl", "msg";
                        };

                        ipi_2_to_ipi_2_nobuf: child@eb3b1000 {
                                phandle = <0x16e>;
                                compatible = "xlnx,versal-ipi-dest-mailbox";
                                xlnx,ipi-bitmask = <0x800>;
                                xlnx,cpu-name = "R52_0";
                                #mbox-cells = <0x1>;
                                xlnx,ipi-id = <0xb>;
                                reg = <0x0 0xeb3b1000 0x0 0x1000>;
                                xlnx,ipi-buf-index = <0xffff>;
                                reg-names = "ctrl";
                        };

                        ipi_2_to_ipi_3: child@eb360000 {
                                phandle = <0x16f>;
                                compatible = "xlnx,versal-ipi-dest-mailbox";
                                xlnx,ipi-bitmask = <0x20>;
                                xlnx,cpu-name = "A78_0";
                                xlnx,ipi-rsp-msg-buf = <0xeb3f0960>;
                                #mbox-cells = <0x1>;
                                xlnx,ipi-id = <0x5>;
                                reg = <0x0 0xeb360000 0x0 0x10000 0x0 0xeb3f0a00 0x0 0x200>;
                                xlnx,ipi-buf-index = <0x5>;
                                xlnx,ipi-req-msg-buf = <0xeb3f0940>;
                                reg-names = "ctrl", "msg";
                        };

                        ipi_2_to_ipi_4: child@eb370000 {
                                phandle = <0x170>;
                                compatible = "xlnx,versal-ipi-dest-mailbox";
                                xlnx,ipi-bitmask = <0x40>;
                                xlnx,cpu-name = "A78_0";
                                xlnx,ipi-rsp-msg-buf = <0xeb3f09a0>;
                                #mbox-cells = <0x1>;
                                xlnx,ipi-id = <0x6>;
                                reg = <0x0 0xeb370000 0x0 0x10000 0x0 0xeb3f0c00 0x0 0x200>;
                                xlnx,ipi-buf-index = <0x6>;
                                xlnx,ipi-req-msg-buf = <0xeb3f0980>;
                                reg-names = "ctrl", "msg";
                        };

                        ipi_2_to_ipi_5: child@eb380000 {
                                phandle = <0x171>;
                                compatible = "xlnx,versal-ipi-dest-mailbox";
                                xlnx,ipi-bitmask = <0x80>;
                                xlnx,cpu-name = "A78_0";
                                xlnx,ipi-rsp-msg-buf = <0xeb3f09e0>;
                                #mbox-cells = <0x1>;
                                xlnx,ipi-id = <0x7>;
                                reg = <0x0 0xeb380000 0x0 0x10000 0x0 0xeb3f0e00 0x0 0x200>;
                                xlnx,ipi-buf-index = <0x7>;
                                xlnx,ipi-req-msg-buf = <0xeb3f09c0>;
                                reg-names = "ctrl", "msg";
                        };

                        ipi_2_to_ipi_6: child@eb3a0000 {
                                phandle = <0x172>;
                                compatible = "xlnx,versal-ipi-dest-mailbox";
                                xlnx,ipi-bitmask = <0x200>;
                                xlnx,cpu-name = "A78_0";
                                #mbox-cells = <0x1>;
                                xlnx,ipi-id = <0x9>;
                                reg = <0x0 0xeb3a0000 0x0 0x10000>;
                                xlnx,ipi-buf-index = <0xffff>;
                                reg-names = "ctrl";
                        };

                        ipi_2_to_ipi_pmc: child@eb320000 {
                                phandle = <0x173>;
                                compatible = "xlnx,versal-ipi-dest-mailbox";
                                xlnx,ipi-bitmask = <0x2>;
                                xlnx,cpu-name = "PMC";
                                xlnx,ipi-rsp-msg-buf = <0xeb3f0860>;
                                #mbox-cells = <0x1>;
                                xlnx,ipi-id = <0x1>;
                                reg = <0x0 0xeb320000 0x0 0x10000 0x0 0xeb3f0200 0x0 0x200>;
                                xlnx,ipi-buf-index = <0x1>;
                                xlnx,ipi-req-msg-buf = <0xeb3f0840>;
                                reg-names = "ctrl", "msg";
                        };

                        ipi_2_to_ipi_pmc_nobuf: child@eb390000 {
                                phandle = <0x174>;
                                compatible = "xlnx,versal-ipi-dest-mailbox";
                                xlnx,ipi-bitmask = <0x100>;
                                xlnx,cpu-name = "PMC";
                                #mbox-cells = <0x1>;
                                xlnx,ipi-id = <0x8>;
                                reg = <0x0 0xeb390000 0x0 0x10000>;
                                xlnx,ipi-buf-index = <0xffff>;
                                reg-names = "ctrl";
                        };
                };

                libmetal_uio_desc099c8000: libmetal_uio_desc0@99c8000 {
                        phandle = <0x1f6>;
                        linux,uio-name = "libmetal-desc0";
                        compatible = "uio";
                        reg = <0x0 0x99c8000 0x0 0x4000>;
                };

                libmetal_uio_desc199cc000: libmetal_uio_desc1@99cc000 {
                        phandle = <0x1f7>;
                        linux,uio-name = "libmetal-desc1";
                        compatible = "uio";
                        reg = <0x0 0x99cc000 0x0 0x4000>;
                };

                libmetal_uio_data99d0000: libmetal_uio_data@99d0000 {
                        phandle = <0x1f8>;
                        linux,uio-name = "libmetal-data";
                        compatible = "uio";
                        reg = <0x0 0x99d0000 0x0 0x40000>;
                };
        };

        scmi_buf: scmi-shmem@20001000 {
                phandle = <0xda>;
                compatible = "arm,scmi-shmem";
                reg = <0x0 0x20001000 0x0 0x1000>;
                no-map;
        };

        reserved-memory {
                ranges;
                #size-cells = <0x2>;
                #address-cells = <0x2>;

                scmi_buffer: memory@20000000 {
                        phandle = <0x1ec>;
                        no-map;
                        reg = <0x0 0x20000000 0x0 0x20000>;
                };

                plm_reserved_memory: plm_reserved_memory@00000000 {
                        phandle = <0x1f9>;
                        label = "plm_reserved_memory";
                        no-map;
                        reg = <0x0 0x0 0x0 0x1000000>;
                };

                tfa_reserved_memory: tfa_reserved_memory@1000000 {
                        phandle = <0x1fa>;
                        label = "tfa_reserved_memory";
                        no-map;
                        reg = <0x0 0x1000000 0x0 0x600000>;
                };

                cma_reserved_800000000: cma_reserved@800000000 {
                        phandle = <0x1fb>;
                        label = "cma_reserved_800000000";
                        compatible = "shared-dma-pool";
                        reusable;
                        linux,cma-default;
                        reg = <0x8 0x0 0x1 0x0>;
                };

                cma_reserved_50000000000: cma_reserved@50000000000 {
                        phandle = <0x1fc>;
                        label = "cma_reserved_50000000000";
                        compatible = "shared-dma-pool";
                        reusable;
                        reg = <0x500 0x0 0x1 0x80000000>;
                };

                asu_firmware: asu_firmware@7ff00000 {
                        phandle = <0x1fd>;
                        label = "asu_firmware";
                        no-map;
                        reg = <0x0 0x7ff00000 0x0 0x100000>;
                };

                ddrboot: ddrboot@9800100 {
                        phandle = <0x201>;
                        label = "ddrboot";
                        mpu-policy = "readable", "writable", "executable", "cacheable", "static";
                        no-map;
                        reg = <0x0 0x9800100 0x0 0x5de00>;
                };

                trace_buffer: trace@985f000 {
                        phandle = <0x202>;
                        label = "trace_buffer";
                        mpu-policy = "readable", "writable";
                        no-map;
                        reg = <0x0 0x985f000 0x0 0x1000>;
                };

                vdev0vring0: vdev0vring0@9880000 {
                        phandle = <0x1fe>;
                        label = "vdev0vring0";
                        no-map;
                        reg = <0x0 0x9880000 0x0 0x4000>;
                };

                vdev0vring1: vdev0vring1@9884000 {
                        phandle = <0x1ff>;
                        label = "vdev0vring1";
                        no-map;
                        reg = <0x0 0x9884000 0x0 0x4000>;
                };

                vdev0buffer: vdev0buffer@9888000 {
                        phandle = <0x200>;
                        label = "vdev0buffer";
                        no-map;
                        reg = <0x0 0x9888000 0x0 0x78000>;
                };

                rsctbl: rsctbl@9800000 {
                        phandle = <0x203>;
                        label = "rsctbl";
                        mpu-policy = "readable", "writable";
                        no-map;
                        reg = <0x0 0x9800000 0x0 0x100>;
                };

                libmetal_elf: libmetal_elf@9968000 {
                        phandle = <0x20a>;
                        label = "libmetal_elf";
                        no-map;
                        reg = <0x0 0x9968000 0x0 0x60000>;
                };

                libmetal_desc0: libmetal_desc0@99c8000 {
                        phandle = <0x207>;
                        label = "libmetal_desc0";
                        no-map;
                        reg = <0x0 0x99c8000 0x0 0x4000>;
                };

                libmetal_desc1: libmetal_desc1@99cc000 {
                        phandle = <0x208>;
                        label = "libmetal_desc1";
                        no-map;
                        reg = <0x0 0x99cc000 0x0 0x4000>;
                };

                libmetal_data: libmetal_data@99d0000 {
                        phandle = <0x209>;
                        label = "libmetal_data";
                        no-map;
                        reg = <0x0 0x99d0000 0x0 0x40000>;
                };
        };

        zynqmp_ipi: zynqmp-ipi {
                phandle = <0x1f2>;
                compatible = "xlnx,zynqmp-ipi-mailbox";
                interrupt-parent = <&gic_r52>;
                interrupts = <0x0 0x39 0x4>;
                xlnx,ipi-id = <0x2>;
                #address-cells = <0x2>;
                #size-cells = <0x2>;
                ranges;

                ipi_mailbox_pmu1: mailbox@eb3f0440 {
                        phandle = <0x1ed>;
                        compatible = "xlnx,zynqmp-ipi-dest-mailbox";
                        reg = <0x0 0xeb3f0440 0x0 0x20 0x0 0xeb3f0460 0x0 0x20 0x0 0xeb3f0280 0x0 0x20 0x0 0xeb3f02a0 0x0 0x20>;
                        reg-names = "local_request_region", "local_response_region", "remote_request_region", "remote_response_region";
                        #mbox-cells = <0x1>;
                        xlnx,ipi-id = <0x1>;
                };
        };

        ref_clk: ref-clk {
                phandle = <0x1ee>;
                bootph-all;
                compatible = "fixed-clock";
                #clock-cells = <0x0>;
                clock-frequency = <0x1fca055>;
                clock-output-names = "board_ref_clk";
        };

        rtc_clk: rtc-clk {
                phandle = <0xf1>;
                bootph-all;
                compatible = "fixed-clock";
                #clock-cells = <0x0>;
                clock-frequency = <0x8000>;
                clock-output-names = "rtc_clk";
        };

        can0_clk: can0-clk {
                phandle = <0xea>;
                #clock-cells = <0x0>;
                compatible = "fixed-factor-clock";
                clocks = <&scmi_clk 0x48>;
                clock-div = <0x2>;
                clock-mult = <0x1>;
        };

        can1_clk: can1-clk {
                phandle = <0xeb>;
                #clock-cells = <0x0>;
                compatible = "fixed-factor-clock";
                clocks = <&scmi_clk 0x4e>;
                clock-div = <0x2>;
                clock-mult = <0x1>;
        };

        can2_clk: can2-clk {
                phandle = <0xec>;
                #clock-cells = <0x0>;
                compatible = "fixed-factor-clock";
                clocks = <&scmi_clk 0x5a>;
                clock-div = <0x2>;
                clock-mult = <0x1>;
        };

        can3_clk: can3-clk {
                phandle = <0xed>;
                #clock-cells = <0x0>;
                compatible = "fixed-factor-clock";
                clocks = <&scmi_clk 0x5d>;
                clock-div = <0x2>;
                clock-mult = <0x1>;
        };

        clk150: clk150 {
                phandle = <0xef>;
                compatible = "fixed-clock";
                #clock-cells = <0x0>;
                clock-frequency = <0x8f0d180>;
        };

        clk250: clk250 {
                phandle = <0xf0>;
                compatible = "fixed-clock";
                #clock-cells = <0x0>;
                clock-frequency = <0xee6b280>;
        };

        clk256: clk256 {
                phandle = <0xf4>;
                compatible = "fixed-clock";
                #clock-cells = <0x0>;
                clock-frequency = <0xf424000>;
        };

        ufs_ref_clk: ufs-ref-clk {
                phandle = <0xf2>;
                compatible = "fixed-clock";
                #clock-cells = <0x0>;
                clock-frequency = <0x18cba80>;
        };

        NoC_C0_C1_ddr_memory: memory@00000000 {
                phandle = <0x4>;
                compatible = "xlnx,axi-noc2-1.1";
                xlnx,ip-name = "axi_noc2";
                device_type = "memory";
                reg = <0x0 0x9968000 0x0 0x60000>;
                memory_type = "memory";
        };

        chosen {
                stdout-path = "serial0:115200n8";
                bootargs = "console=ttyAMA0,115200";
        };

        pwm_fan: pwm-fan {
                phandle = <0x1f3>;
                compatible = "pwm-fan";
        };

        usb_hub_delay: enable-delay {
                phandle = <0xf3>;
                compatible = "gpio-delay";
                #gpio-cells = <0x3>;
                gpio-controller;
        };

        __symbols__ {
                cpu_opp_table = "/opp-table";
                cpus_r52_1 = "/cpus-r52@1";
                cortexr52_1 = "/cpus-r52@1/cpu@0";
                psci = "/firmware/psci";
                scmi = "/firmware/scmi";
                scmi_reset = "/firmware/scmi/protocol@16";
                scmi_devpd = "/firmware/scmi/protocol@11";
                scmi_clk = "/firmware/scmi/protocol@14";
                versal2_firmware = "/firmware/versal2-firmware";
                versal_sec_cfg = "/firmware/versal2-firmware/versal-sec-cfg";
                bbram_zeroize = "/firmware/versal2-firmware/versal-sec-cfg/nvmem-layout/bbram-zeroize@4";
                bbram_key = "/firmware/versal2-firmware/versal-sec-cfg/nvmem-layout/bbram-key@10";
                bbram_usr = "/firmware/versal2-firmware/versal-sec-cfg/nvmem-layout/bbram-usr@30";
                bbram_lock = "/firmware/versal2-firmware/versal-sec-cfg/nvmem-layout/bbram-lock@48";
                user_key0 = "/firmware/versal2-firmware/versal-sec-cfg/nvmem-layout/user-key@110";
                user_key1 = "/firmware/versal2-firmware/versal-sec-cfg/nvmem-layout/user-key@130";
                user_key2 = "/firmware/versal2-firmware/versal-sec-cfg/nvmem-layout/user-key@150";
                user_key3 = "/firmware/versal2-firmware/versal-sec-cfg/nvmem-layout/user-key@170";
                user_key4 = "/firmware/versal2-firmware/versal-sec-cfg/nvmem-layout/user-key@190";
                user_key5 = "/firmware/versal2-firmware/versal-sec-cfg/nvmem-layout/user-key@1b0";
                user_key6 = "/firmware/versal2-firmware/versal-sec-cfg/nvmem-layout/user-key@1d0";
                user_key7 = "/firmware/versal2-firmware/versal-sec-cfg/nvmem-layout/user-key@1f0";
                fpga = "/fpga-region";
                timer = "/timer";
                versal_fpga = "/versal-fpga";
                amba_apu = "/apu-bus";
                amba_rpu = "/rpu-bus";
                gic_r52 = "/rpu-bus/interrupt-controller@e2000000";
                sensor0 = "/versal-thermal-sensor";
                versal_thermal = "/thermal-zones/versal-thermal";
                temp_alert = "/thermal-zones/versal-thermal/trips/temp-alert";
                ot_crit = "/thermal-zones/versal-thermal/trips/ot-crit";
                versal_thermal_aie = "/thermal-zones/versal-aie-thermal";
                temp_alert_aie = "/thermal-zones/versal-aie-thermal/trips/temp-alert-aie";
                ot_crit_aie = "/thermal-zones/versal-aie-thermal/trips/ot-crit-aie";
                amba = "/axi";
                i2c0 = "/axi/i2c@f1940000";
                serial0 = "/axi/serial@f1920000";
                ttc3 = "/axi/timer@f1e90000";
                ipi2 = "/axi/mailbox@eb350000";
                ipi_2_to_ipi_asu = "/axi/mailbox@eb350000/child@eb310000";
                ipi_2_to_ipi_0 = "/axi/mailbox@eb350000/child@eb330000";
                ipi_2_to_ipi_1 = "/axi/mailbox@eb350000/child@eb340000";
                ipi_2_to_ipi_1_nobuf = "/axi/mailbox@eb350000/child@eb3b0000";
                ipi_2_to_ipi_2 = "/axi/mailbox@eb350000/child@eb350000";
                ipi_2_to_ipi_2_nobuf = "/axi/mailbox@eb350000/child@eb3b1000";
                ipi_2_to_ipi_3 = "/axi/mailbox@eb350000/child@eb360000";
                ipi_2_to_ipi_4 = "/axi/mailbox@eb350000/child@eb370000";
                ipi_2_to_ipi_5 = "/axi/mailbox@eb350000/child@eb380000";
                ipi_2_to_ipi_6 = "/axi/mailbox@eb350000/child@eb3a0000";
                ipi_2_to_ipi_pmc = "/axi/mailbox@eb350000/child@eb320000";
                ipi_2_to_ipi_pmc_nobuf = "/axi/mailbox@eb350000/child@eb390000";
                scmi_buf = "/scmi-shmem@20001000";
                scmi_buffer = "/reserved-memory/memory@20000000";
                ipi_mailbox_pmu1 = "/zynqmp-ipi/mailbox@eb3f0440";
                ref_clk = "/ref-clk";
                rtc_clk = "/rtc-clk";
                can0_clk = "/can0-clk";
                can1_clk = "/can1-clk";
                can2_clk = "/can2-clk";
                can3_clk = "/can3-clk";
                clk150 = "/clk150";
                clk250 = "/clk250";
                clk256 = "/clk256";
                ufs_ref_clk = "/ufs-ref-clk";
                NoC_C0_C1_ddr_memory = "/memory@00000000";
                usb_hub_delay = "/enable-delay";
                libmetal_uio_desc099c8000 = "/axi/libmetal_uio_desc0@99c8000";
                libmetal_uio_desc199cc000 = "/axi/libmetal_uio_desc1@99cc000";
                libmetal_uio_data99d0000 = "/axi/libmetal_uio_data@99d0000";
                plm_reserved_memory = "/reserved-memory/plm_reserved_memory@00000000";
                tfa_reserved_memory = "/reserved-memory/tfa_reserved_memory@1000000";
                cma_reserved_800000000 = "/reserved-memory/cma_reserved@800000000";
                cma_reserved_50000000000 = "/reserved-memory/cma_reserved@50000000000";
                asu_firmware = "/reserved-memory/asu_firmware@7ff00000";
                ddrboot = "/reserved-memory/ddrboot@9800100";
                trace_buffer = "/reserved-memory/trace@985f000";
                vdev0vring0 = "/reserved-memory/vdev0vring0@9880000";
                vdev0vring1 = "/reserved-memory/vdev0vring1@9884000";
                vdev0buffer = "/reserved-memory/vdev0buffer@9888000";
                rsctbl = "/reserved-memory/rsctbl@9800000";
                libmetal_elf = "/reserved-memory/libmetal_elf@9968000";
                libmetal_desc0 = "/reserved-memory/libmetal_desc0@99c8000";
                libmetal_desc1 = "/reserved-memory/libmetal_desc1@99cc000";
                libmetal_data = "/reserved-memory/libmetal_data@99d0000";
                zynqmp_ipi = "/zynqmp-ipi";
                pwm_fan = "/pwm-fan";
        };

        domains {

                sdt_all_devices {
                        board = "amd,versal2-vmk365-revA";
                        compatible = "openamp,domain-v1,devices";
                        cpus = <&cpus_r52_1 0x1 0x0>;
                        id = <0x0>;
                        memory = <0x0 0x20000000 0x0 0x20000 0x0 0xbeef 0x0 0x80000000 0x8 0x0 0x1 0x80000000 0x500 0x0 0x2 0x0 0x0 0xbbf00000 0x0 0x80000 0x0 0xbbf80000 0x0 0x80000>;
                        model = "AMD Versal VMK365 revA";
                        soc_family = "amd,versal2";
                        sram = <0x0 0x4 0x0 0x4 0x0 0x10 0x0 0x20 0x0 0x30 0x0 0x4 0x0 0x48 0x0 0x4 0x0 0xeba00000 0x0 0x10000 0x0 0xeba10000 0x0 0x8000 0x0 0xeba20000 0x0 0x8000 0x0 0xeba80000 0x0 0x10000 0x0 0xeba90000 0x0 0x8000 0x0 0xebaa0000 0x0 0x8000 0x0 0xebb00000 0x0 0x10000 0x0 0xebb10000 0x0 0x8000 0x0 0xebb20000 0x0 0x8000 0x0 0xeba40000 0x0 0x10000 0x0 0xeba50000 0x0 0x8000 0x0 0xeba60000 0x0 0x8000 0x0 0xebac0000 0x0 0x10000 0x0 0xebad0000 0x0 0x8000 0x0 0xebae0000 0x0 0x8000 0x0 0xebb40000 0x0 0x10000 0x0 0xebb50000 0x0 0x8000 0x0 0xebb60000 0x0 0x8000 0x0 0xf11f0000 0x0 0x10000 0x0 0xeb5d0000 0x0 0x10000 0x0 0xeb400000 0x0 0x10000 0x0 0xeb960000 0x0 0x10000 0x0 0xeb980000 0x0 0x10000 0x0 0xbeef 0x0 0x100000>;

                        aliases {
                                i2c1 = "/axi/i2c@f1940000";
                                serial0 = "/axi/serial@f1920000";
                        };
                };

                APU_Linux {
                        phandle = <0x206>;
                        compatible = "openamp,domain-v1";
                        lopper,activate = "linux";
                        access = <&psci 0x0>,
                         <&scmi 0x0>,
                         <&versal2_firmware 0x0>,
                         <&ipi2 0x0>,
                         <&cpu_opp_table 0x0>,
                         <&fpga 0x0>,
                         <&timer 0x0>,
                         <&versal_fpga 0x0>,
                         <&amba_rpu 0x0>,
                         <&sensor0 0x0>,
                         <&scmi_buf 0x0>,
                         <&zynqmp_ipi 0x0>,
                         <&pwm_fan 0x0>,
                         <&usb_hub_delay 0x0>,
                         <&ttc3 0x0>,
                         <&libmetal_uio_desc099c8000 0x0>,
                         <&libmetal_uio_desc199cc000 0x0>,
                         <&libmetal_uio_data99d0000 0x0>;
                        reserved-memory = <0x1f9 0x1fa 0x1fb 0x1fc 0x1fd 0x1fe 0x1ff 0x200 0x201 0x202 0x203>;
                        os,type = "linux";
                        lopper,access-keep-all = <0x1>;
                        access-json = "[{\"dev\": \"interrupt-controller@e2000000\", \"label\": \"gic_a78\"}, {\"dev\": \"gpu@ed000000\", \"label\": \"gpu\"}, {\"dev\": \"mmi_dptx@ede00000\", \"label\": \"mmi_dptx\"}, {\"dev\": \"dma-controller@edd10000\", \"label\": \"mmi_dcdma\"}, {\"dev\": \"mmi_dc@edd00000\", \"label\": \"mmi_dc\"}, {\"dev\": \"dma-controller@ebd00000\", \"label\": \"adma0\"}, {\"dev\": \"dma-controller@ebd10000\", \"label\": \"adma1\"}, {\"dev\": \"dma-controller@ebd20000\", \"label\": \"adma2\"}, {\"dev\": \"dma-controller@ebd30000\", \"label\": \"adma3\"}, {\"dev\": \"dma-controller@ebd40000\", \"label\": \"adma4\"}, {\"dev\": \"dma-controller@ebd50000\", \"label\": \"adma5\"}, {\"dev\": \"dma-controller@ebd60000\", \"label\": \"adma6\"}, {\"dev\": \"dma-controller@ebd70000\", \"label\": \"adma7\"}, {\"dev\": \"can@f19e0000\", \"label\": \"can0\", \"status\": \"disabled\"}, {\"dev\": \"can@f19f0000\", \"label\": \"can1\", \"status\": \"disabled\"}, {\"dev\": \"can@f1a00000\", \"label\": \"can2\", \"status\": \"disabled\"}, {\"dev\": \"can@f1a10000\", \"label\": \"can3\", \"status\": \"disabled\"}, {\"dev\": \"can@f1a90000\", \"label\": \"can4\", \"status\": \"disabled\"}, {\"dev\": \"can@f1aa0000\", \"label\": \"can5\", \"status\": \"disabled\"}, {\"dev\": \"pmcdma@f11c0000\", \"label\": \"dma0\"}, {\"dev\": \"pmcdma@f11d0000\", \"label\": \"dma1\"}, {\"dev\": \"asudma@ebe8c000\", \"label\": \"asu_dma0\"}, {\"dev\": \"asudma@ebe8d000\", \"label\": \"asu_dma1\"}, {\"dev\": \"ethernet@f1a60000\", \"label\": \"gem0\", \"status\": \"disabled\"}, {\"dev\": \"ethernet@f1a70000\", \"label\": \"gem1\"}, {\"dev\": \"ethernet@ed920000\", \"label\": \"mmi_10gbe\"}, {\"dev\": \"gpio@f1a50000\", \"label\": \"gpio0\"}, {\"dev\": \"gpio@f1020000\", \"label\": \"gpio1\"}, {\"bootph\": \"all\", \"dev\": \"i2c@f1950000\", \"label\": \"i2c1\"}, {\"dev\": \"i2c@f1960000\", \"label\": \"i2c2\", \"status\": \"disabled\"}, {\"dev\": \"i2c@f1970000\", \"label\": \"i2c3\", \"status\": \"disabled\"}, {\"dev\": \"i2c@f1980000\", \"label\": \"i2c4\", \"status\": \"disabled\"}, {\"dev\": \"i2c@f1990000\", \"label\": \"i2c5\", \"status\": \"disabled\"}, {\"dev\": \"i2c@f19a0000\", \"label\": \"i2c6\", \"status\": \"disabled\"}, {\"dev\": \"i2c@f19b0000\", \"label\": \"i2c7\", \"status\": \"disabled\"}, {\"dev\": \"i2c@f1000000\", \"label\": \"i2c8\"}, {\"dev\": \"i3c@f1948000\", \"label\": \"i3c0\", \"status\": \"disabled\"}, {\"dev\": \"i3c@f1958000\", \"label\": \"i3c1\", \"status\": \"disabled\"}, {\"dev\": \"i3c@f1968000\", \"label\": \"i3c2\", \"status\": \"disabled\"}, {\"dev\": \"i3c@f1978000\", \"label\": \"i3c3\", \"status\": \"disabled\"}, {\"dev\": \"i3c@f1988000\", \"label\": \"i3c4\", \"status\": \"disabled\"}, {\"dev\": \"i3c@f1998000\", \"label\": \"i3c5\", \"status\": \"disabled\"}, {\"dev\": \"i3c@f19a8000\", \"label\": \"i3c6\", \"status\": \"disabled\"}, {\"dev\": \"i3c@f19b8000\", \"label\": \"i3c7\", \"status\": \"disabled\"}, {\"dev\": \"i3c@f1008000\", \"label\": \"i3c8\", \"status\": \"disabled\"}, {\"dev\": \"iomodule@f0300000\", \"label\": \"iomodule0\"}, {\"dev\": \"iomodule@ebe80000\", \"label\": \"asu_iomodule0\"}, {\"dev\": \"spi@f1010000\", \"label\": \"ospi\"}, {\"dev\": \"watchdog@f03f0000\", \"label\": \"pmc_wwdt\", \"status\": \"disabled\"}, {\"dev\": \"rng@f1230000\", \"label\": \"trng\"}, {\"dev\": \"cframe@f12d0000\", \"label\": \"pmc_cfi_cframe_0\"}, {\"dev\": \"cfu_apb@f12b0000\", \"label\": \"pmc_cfu_apb_0\"}, {\"dev\": \"ppu1_mdm@f0310000\", \"label\": \"pmc_ppu1_mdm_0\"}, {\"dev\": \"spi@f1030000\", \"label\": \"qspi\", \"status\": \"disabled\"}, {\"dev\": \"rtc@f12a0000\", \"label\": \"rtc\"}, {\"dev\": \"mmc@f1040000\", \"label\": \"sdhci0\"}, {\"dev\": \"mmc@f1050000\", \"label\": \"sdhci1\", \"status\": \"disabled\"}, {\"bootph\": \"all\", \"dev\": \"serial@f1930000\", \"label\": \"serial1\"}, {\"dev\": \"spi@f19c0000\", \"label\": \"spi0\", \"status\": \"disabled\"}, {\"dev\": \"spi@f19d0000\", \"label\": \"spi1\", \"status\": \"disabled\"}, {\"dev\": \"sysmon@f1270000\", \"label\": \"sysmon0\"}, {\"dev\": \"timer@f1e60000\", \"label\": \"ttc0\"}, {\"dev\": \"timer@f1e70000\", \"label\": \"ttc1\"}, {\"dev\": \"timer@f1ea0000\", \"label\": \"ttc4\"}, {\"dev\": \"timer@f1eb0000\", \"label\": \"ttc5\"}, {\"dev\": \"timer@f1ec0000\", \"label\": \"ttc6\"}, {\"dev\": \"timer@f1ed0000\", \"label\": \"ttc7\"}, {\"dev\": \"ufs@f10b0000\", \"label\": \"ufshc\"}, {\"dev\": \"usb@f1ee0000\", \"label\": \"usb0\"}, {\"dev\": \"usb@f1ef0000\", \"label\": \"usb1\", \"status\": \"disabled\"}, {\"dev\": \"phy@edeb8000\", \"label\": \"usb3_dp_phy\"}, {\"dev\": \"pcie@ed931000\", \"label\": \"mdb_pcie0\"}, {\"dev\": \"pcie@ed939000\", \"label\": \"mdb_pcie1\", \"status\": \"disabled\"}, {\"dev\": \"watchdog@ecc10000\", \"label\": \"wwdt0\", \"status\": \"disabled\"}, {\"dev\": \"watchdog@ecd10000\", \"label\": \"wwdt1\", \"status\": \"disabled\"}, {\"dev\": \"watchdog@ece10000\", \"label\": \"wwdt2\", \"status\": \"disabled\"}, {\"dev\": \"watchdog@ecf10000\", \"label\": \"wwdt3\", \"status\": \"disabled\"}, {\"dev\": \"edac@f2014050\", \"label\": \"xilsem_edac\", \"status\": \"disabled\"}, {\"dev\": \"watchdog@eb000000\", \"label\": \"lpd_wwdt0\", \"status\": \"disabled\"}, {\"dev\": \"watchdog@eb010000\", \"label\": \"lpd_wwdt1\", \"status\": \"disabled\"}, {\"dev\": \"watchdog@eb020000\", \"label\": \"lpd_wwdt2\", \"status\": \"disabled\"}, {\"dev\": \"watchdog@eb030000\", \"label\": \"lpd_wwdt3\", \"status\": \"disabled\"}, {\"dev\": \"watchdog@eb040000\", \"label\": \"lpd_wwdt4\", \"status\": \"disabled\"}, {\"dev\": \"coresight@f0800000\", \"label\": \"coresight\"}, {\"dev\": \"mailbox@eb330000\", \"label\": \"ipi0\"}, {\"dev\": \"mailbox@eb370000\", \"label\": \"ipi4\"}, {\"dev\": \"mailbox@eb380000\", \"label\": \"ipi5\"}, {\"dev\": \"mailbox@eb3a0000\", \"label\": \"ipi6\"}, {\"dev\": \"mailbox@eb3b0000\", \"label\": \"ipi_nobuf1\"}, {\"dev\": \"mailbox@eb3b2000\", \"label\": \"ipi_nobuf3\", \"status\": \"disabled\"}, {\"dev\": \"mailbox@eb3b3000\", \"label\": \"ipi_nobuf4\", \"status\": \"disabled\"}, {\"dev\": \"mailbox@eb3b4000\", \"label\": \"ipi_nobuf5\", \"status\": \"disabled\"}, {\"dev\": \"mailbox@eb3b5000\", \"label\": \"ipi_nobuf6\", \"status\": \"disabled\"}, {\"dev\": \"mailbox@eb310000\", \"label\": \"ipi_asu\"}, {\"dev\": \"mailbox@eb320000\", \"label\": \"ipi_pmc\"}, {\"dev\": \"mailbox@eb390000\", \"label\": \"ipi_pmc_nobuf\"}, {\"dev\": \"r52_0b_atcm_global@eba80000\", \"label\": \"r52_0b_atcm_global\"}, {\"dev\": \"r52_0b_btcm_global@eba90000\", \"label\": \"r52_0b_btcm_global\"}, {\"dev\": \"r52_0b_ctcm_global@ebaa0000\", \"label\": \"r52_0b_ctcm_global\"}, {\"dev\": \"r52_0c_atcm_global@ebb00000\", \"label\": \"r52_0c_atcm_global\"}, {\"dev\": \"r52_0c_btcm_global@ebb10000\", \"label\": \"r52_0c_btcm_global\"}, {\"dev\": \"r52_0c_ctcm_global@ebb20000\", \"label\": \"r52_0c_ctcm_global\"}, {\"dev\": \"r52_1a_atcm_global@eba40000\", \"label\": \"r52_1a_atcm_global\"}, {\"dev\": \"r52_1a_btcm_global@eba50000\", \"label\": \"r52_1a_btcm_global\"}, {\"dev\": \"r52_1a_ctcm_global@eba60000\", \"label\": \"r52_1a_ctcm_global\"}, {\"dev\": \"r52_1b_atcm_global@ebac0000\", \"label\": \"r52_1b_atcm_global\"}, {\"dev\": \"r52_1b_btcm_global@ebad0000\", \"label\": \"r52_1b_btcm_global\"}, {\"dev\": \"r52_1b_ctcm_global@ebae0000\", \"label\": \"r52_1b_ctcm_global\"}, {\"dev\": \"r52_1c_atcm_global@ebb40000\", \"label\": \"r52_1c_atcm_global\"}, {\"dev\": \"r52_1c_btcm_global@ebb50000\", \"label\": \"r52_1c_btcm_global\"}, {\"dev\": \"r52_1c_ctcm_global@ebb60000\", \"label\": \"r52_1c_ctcm_global\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-aes@f11e0000\", \"label\": \"ps_wizard_0_ps11_0_pmc_aes\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-aes@ebe88000\", \"label\": \"ps_wizard_0_ps11_0_asu_aes\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-ecc@ebf00000\", \"label\": \"ps_wizard_0_ps11_0_asu_ecc\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-global@ebf80000\", \"label\": \"ps_wizard_0_ps11_0_asu_global\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-keys@ebe8a000\", \"label\": \"ps_wizard_0_ps11_0_asu_keys\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-local@ebe8e000\", \"label\": \"ps_wizard_0_ps11_0_asu_local\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-mdm-hsd@ebef0000\", \"label\": \"ps_wizard_0_ps11_0_asu_mdm_hsd\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-ram-data-cntlr@ebe40000\", \"label\": \"ps_wizard_0_ps11_0_asu_ram_data_cntlr\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-ram-data-ecc-ctrl@ebeb0000\", \"label\": \"ps_wizard_0_ps11_0_asu_ram_data_ecc_ctrl\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-ram-instr-cntlr@ebe00000\", \"label\": \"ps_wizard_0_ps11_0_asu_ram_instr_cntlr\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-ram-instr-ecc-ctrl@ebea0000\", \"label\": \"ps_wizard_0_ps11_0_asu_ram_instr_ecc_ctrl\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-rsa@ebf50000\", \"label\": \"ps_wizard_0_ps11_0_asu_rsa\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-sha2@ebf30000\", \"label\": \"ps_wizard_0_ps11_0_asu_sha2\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-sha3@ebf40000\", \"label\": \"ps_wizard_0_ps11_0_asu_sha3\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-tmr-inject@ebed0000\", \"label\": \"ps_wizard_0_ps11_0_asu_tmr_inject\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-tmr-manager@ebec0000\", \"label\": \"ps_wizard_0_ps11_0_asu_tmr_manager\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-tmr-trace@ebee0000\", \"label\": \"ps_wizard_0_ps11_0_asu_tmr_trace\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-trng@ebf20000\", \"label\": \"ps_wizard_0_ps11_0_asu_trng\"}, {\"dev\": \"ps-wizard-0-ps11-0-asu-xmpu@ebf60000\", \"label\": \"ps_wizard_0_ps11_0_asu_xmpu\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-bbram-ctrl@f11f0000\", \"label\": \"ps_wizard_0_ps11_0_pmc_bbram_ctrl\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-10@f12e4000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_10\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-11@f12e6000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_11\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-12@f12e8000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_12\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-13@f12ea000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_13\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-14@f12ec000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_14\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-1@f12d2000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_1\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-2@f12d4000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_2\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-3@f12d6000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_3\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-4@f12d8000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_4\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-5@f12da000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_5\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-6@f12dc000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_6\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-7@f12de000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_7\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-8@f12e0000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_8\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-9@f12e2000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_9\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-cfi-cframe-bcast@f12ee000\", \"label\": \"ps_wizard_0_ps11_0_pmc_cfi_cframe_bcast\"}, {\"dev\": \"ps-wizard-0-ps11-0-cpm-cdx-dpu-high@100000000000\", \"label\": \"ps_wizard_0_ps11_0_cpm_cdx_dpu_high\"}, {\"dev\": \"ps-wizard-0-ps11-0-crf-0@ec200000\", \"label\": \"ps_wizard_0_ps11_0_crf_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-crl-0@eb5e0000\", \"label\": \"ps_wizard_0_ps11_0_crl_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-crp-0@f1260000\", \"label\": \"ps_wizard_0_ps11_0_crp_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-coresight-fpd-stm@f0c40000\", \"label\": \"ps_wizard_0_ps11_0_coresight_fpd_stm\"}, {\"dev\": \"ps-wizard-0-ps11-0-coresight-lpd-atm@f08f0000\", \"label\": \"ps_wizard_0_ps11_0_coresight_lpd_atm\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-rsa@f1200000\", \"label\": \"ps_wizard_0_ps11_0_pmc_rsa\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-efuse-cache@f1250000\", \"label\": \"ps_wizard_0_ps11_0_pmc_efuse_cache\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-efuse-ctrl@f1240000\", \"label\": \"ps_wizard_0_ps11_0_pmc_efuse_ctrl\"}, {\"dev\": \"ps-wizard-0-ps11-0-fpd-afi-0@ec880000\", \"label\": \"ps_wizard_0_ps11_0_fpd_afi_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-fpd-afi-mem-0@b0000000\", \"label\": \"ps_wizard_0_ps11_0_fpd_afi_mem_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-apu-0@ecc00000\", \"label\": \"ps_wizard_0_ps11_0_apu_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-fpd-cmn@f8000000\", \"label\": \"ps_wizard_0_ps11_0_fpd_cmn\"}, {\"dev\": \"ps-wizard-0-ps11-0-fpd-cmn-xmpu@ec830000\", \"label\": \"ps_wizard_0_ps11_0_fpd_cmn_xmpu\"}, {\"dev\": \"ps-wizard-0-ps11-0-fpd-slcr-0@ec8c0000\", \"label\": \"ps_wizard_0_ps11_0_fpd_slcr_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-fpd-slcr-secure-0@ec8e0000\", \"label\": \"ps_wizard_0_ps11_0_fpd_slcr_secure_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-fpd-slv-asilb-xmpu-0@ec820000\", \"label\": \"ps_wizard_0_ps11_0_fpd_slv_asilb_xmpu_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-fpd-slv-asild-xmpu-0@ec810000\", \"label\": \"ps_wizard_0_ps11_0_fpd_slv_asild_xmpu_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-fpd-splitter-0@ecc20000\", \"label\": \"ps_wizard_0_ps11_0_fpd_splitter_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-fpd-splitter-1@ecd20000\", \"label\": \"ps_wizard_0_ps11_0_fpd_splitter_1\"}, {\"dev\": \"ps-wizard-0-ps11-0-fpd-systmr-ctrl@ec920000\", \"label\": \"ps_wizard_0_ps11_0_fpd_systmr_ctrl\"}, {\"dev\": \"ps-wizard-0-ps11-0-fpd-systmr-read@ec910000\", \"label\": \"ps_wizard_0_ps11_0_fpd_systmr_read\"}, {\"dev\": \"ps-wizard-0-ps11-0-intasu-config@ebf70000\", \"label\": \"ps_wizard_0_ps11_0_intasu_config\"}, {\"dev\": \"ps-wizard-0-ps11-0-intasu-gpv@ebf7f000\", \"label\": \"ps_wizard_0_ps11_0_intasu_gpv\"}, {\"dev\": \"ps-wizard-0-ps11-0-intfpd-asilb-config@ec500000\", \"label\": \"ps_wizard_0_ps11_0_intfpd_asilb_config\"}, {\"dev\": \"ps-wizard-0-ps11-0-intfpd-asilb-gpv@ec804000\", \"label\": \"ps_wizard_0_ps11_0_intfpd_asilb_gpv\"}, {\"dev\": \"ps-wizard-0-ps11-0-intfpd-asild-config@ec400000\", \"label\": \"ps_wizard_0_ps11_0_intfpd_asild_config\"}, {\"dev\": \"ps-wizard-0-ps11-0-intfpd-asild-gpv@ec800000\", \"label\": \"ps_wizard_0_ps11_0_intfpd_asild_gpv\"}, {\"dev\": \"ps-wizard-0-ps11-0-ipi-buffer@eb3f0000\", \"label\": \"ps_wizard_0_ps11_0_ipi_buffer\"}, {\"dev\": \"ps-wizard-0-ps11-0-lpd-afi-0@eb9b0000\", \"label\": \"ps_wizard_0_ps11_0_lpd_afi_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-lpd-iou-secure-slcr-0@f1a40000\", \"label\": \"ps_wizard_0_ps11_0_lpd_iou_secure_slcr_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-lpd-iou-slcr-0@f1a20000\", \"label\": \"ps_wizard_0_ps11_0_lpd_iou_slcr_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-lpd-slcr-0@eb410000\", \"label\": \"ps_wizard_0_ps11_0_lpd_slcr_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-lpd-slcr-secure-0@eb510000\", \"label\": \"ps_wizard_0_ps11_0_lpd_slcr_secure_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-lpd-systmr-ctrl@ea470000\", \"label\": \"ps_wizard_0_ps11_0_lpd_systmr_ctrl\"}, {\"dev\": \"ps-wizard-0-ps11-0-lpd-systmr-read@ea460000\", \"label\": \"ps_wizard_0_ps11_0_lpd_systmr_read\"}, {\"dev\": \"ps-wizard-0-ps11-0-lpd-xppu-0@eb990000\", \"label\": \"ps_wizard_0_ps11_0_lpd_xppu_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-mmi-common@eda00000\", \"label\": \"ps_wizard_0_ps11_0_mmi_common\"}, {\"dev\": \"ps-wizard-0-ps11-0-mmi-dpdma@edd10000\", \"label\": \"ps_wizard_0_ps11_0_mmi_dpdma\"}, {\"dev\": \"ps-wizard-0-ps11-0-mmi-gtyp-cfg@ed900000\", \"label\": \"ps_wizard_0_ps11_0_mmi_gtyp_cfg\"}, {\"dev\": \"ps-wizard-0-ps11-0-mmi-hdcp@edeb0000\", \"label\": \"ps_wizard_0_ps11_0_mmi_hdcp\"}, {\"dev\": \"ps-wizard-0-ps11-0-mmi-pcie0@ed800000\", \"label\": \"ps_wizard_0_ps11_0_mmi_pcie0\"}, {\"dev\": \"ps-wizard-0-ps11-0-mmi-pipe-gem-slcr@ed930000\", \"label\": \"ps_wizard_0_ps11_0_mmi_pipe_gem_slcr\"}, {\"dev\": \"ps-wizard-0-ps11-0-mmi-trng@ede80000\", \"label\": \"ps_wizard_0_ps11_0_mmi_trng\"}, {\"dev\": \"ps-wizard-0-ps11-0-mmi-udh-pll@ede90000\", \"label\": \"ps_wizard_0_ps11_0_mmi_udh_pll\"}, {\"dev\": \"ps-wizard-0-ps11-0-mmi-udh-slcr@edea0000\", \"label\": \"ps_wizard_0_ps11_0_mmi_udh_slcr\"}, {\"dev\": \"ps-wizard-0-ps11-0-mmi-usb2phy@edebc000\", \"label\": \"ps_wizard_0_ps11_0_mmi_usb2phy\"}, {\"dev\": \"ps-wizard-0-ps11-0-mmi-usb3phy-crpara@ede40000\", \"label\": \"ps_wizard_0_ps11_0_mmi_usb3phy_crpara\"}, {\"dev\": \"ps-wizard-0-ps11-0-noc-pcie-0@a0000000\", \"label\": \"ps_wizard_0_ps11_0_noc_pcie_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-ocm-ctrl-0@eb5d0000\", \"label\": \"ps_wizard_0_ps11_0_ocm_ctrl_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-ocm-xmpu-0@eb400000\", \"label\": \"ps_wizard_0_ps11_0_ocm_xmpu_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-ocm-ctrl-1@eb960000\", \"label\": \"ps_wizard_0_ps11_0_ocm_ctrl_1\"}, {\"dev\": \"ps-wizard-0-ps11-0-ocm-xmpu-1@eb980000\", \"label\": \"ps_wizard_0_ps11_0_ocm_xmpu_1\"}, {\"dev\": \"ps-wizard-0-ps11-0-mmi-pcie-region-0@a0000000\", \"label\": \"ps_wizard_0_ps11_0_mmi_pcie_region_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-global-0@f1110000\", \"label\": \"ps_wizard_0_ps11_0_pmc_global_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-ram@f2000000\", \"label\": \"ps_wizard_0_ps11_0_pmc_ram\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-ram-npi@f6000000\", \"label\": \"ps_wizard_0_ps11_0_pmc_ram_npi\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-slave-boot@f1220000\", \"label\": \"ps_wizard_0_ps11_0_pmc_slave_boot\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-slave-boot-stream@f2100000\", \"label\": \"ps_wizard_0_ps11_0_pmc_slave_boot_stream\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-xmpu-0@f12f0000\", \"label\": \"ps_wizard_0_ps11_0_pmc_xmpu_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-xppu-0@f1310000\", \"label\": \"ps_wizard_0_ps11_0_pmc_xppu_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-xppu-npi-0@f1300000\", \"label\": \"ps_wizard_0_ps11_0_pmc_xppu_npi_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-tmr-inject-0@f0083000\", \"label\": \"ps_wizard_0_ps11_0_pmc_tmr_inject_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-ram-data-cntlr@f0280000\", \"label\": \"ps_wizard_0_ps11_0_pmc_ram_data_cntlr\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-ram-instr-cntlr@f0200000\", \"label\": \"ps_wizard_0_ps11_0_pmc_ram_instr_cntlr\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-tmr-manager-0@f0303000\", \"label\": \"ps_wizard_0_ps11_0_pmc_tmr_manager_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-r52-tcm-alias@0\", \"label\": \"ps_wizard_0_ps11_0_r52_tcm_alias\"}, {\"dev\": \"ps-wizard-0-ps11-0-rpu-a@eb580000\", \"label\": \"ps_wizard_0_ps11_0_rpu_a\"}, {\"dev\": \"ps-wizard-0-ps11-0-rpu-b@eb590000\", \"label\": \"ps_wizard_0_ps11_0_rpu_b\"}, {\"dev\": \"ps-wizard-0-ps11-0-rpu-c@eb5a0000\", \"label\": \"ps_wizard_0_ps11_0_rpu_c\"}, {\"dev\": \"ps-wizard-0-ps11-0-sdma-0@ebd80000\", \"label\": \"ps_wizard_0_ps11_0_sdma_0\"}, {\"dev\": \"ps-wizard-0-ps11-0-sdma-1@ebd90000\", \"label\": \"ps_wizard_0_ps11_0_sdma_1\"}, {\"dev\": \"ps-wizard-0-ps11-0-sdma-2@ebda0000\", \"label\": \"ps_wizard_0_ps11_0_sdma_2\"}, {\"dev\": \"ps-wizard-0-ps11-0-sdma-3@ebdb0000\", \"label\": \"ps_wizard_0_ps11_0_sdma_3\"}, {\"dev\": \"ps-wizard-0-ps11-0-sdma-4@ebdc0000\", \"label\": \"ps_wizard_0_ps11_0_sdma_4\"}, {\"dev\": \"ps-wizard-0-ps11-0-sdma-5@ebdd0000\", \"label\": \"ps_wizard_0_ps11_0_sdma_5\"}, {\"dev\": \"ps-wizard-0-ps11-0-sdma-6@ebde0000\", \"label\": \"ps_wizard_0_ps11_0_sdma_6\"}, {\"dev\": \"ps-wizard-0-ps11-0-sdma-7@ebdf0000\", \"label\": \"ps_wizard_0_ps11_0_sdma_7\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-sha2@f1800000\", \"label\": \"ps_wizard_0_ps11_0_pmc_sha2\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-sha3@f1210000\", \"label\": \"ps_wizard_0_ps11_0_pmc_sha3\"}, {\"dev\": \"ps-wizard-0-ps11-0-pmc-ufs-0@f10a0000\", \"label\": \"ps_wizard_0_ps11_0_pmc_ufs_0\"}, {\"dev\": \"vcu2@e8000000\", \"label\": \"VCU_hier_vcu2_0\"}, {\"dev\": \"ale2xx@e8040000\", \"label\": \"encoder\"}, {\"dev\": \"ald3xx@e8080000\", \"label\": \"decoder\"}, {\"dev\": \"psci\"}, {\"bootph\": \"all\", \"dev\": \"scmi\"}, {\"bootph\": \"all\", \"dev\": \"versal2_firmware\"}, {\"dev\": \"ipi0\", \"label\": \"ipi0\"}, {\"dev\": \"ipi1\", \"label\": \"ipi1\"}, {\"dev\": \"ipi2\", \"label\": \"ipi2\"}, {\"dev\": \"ipi3\", \"label\": \"ipi3\"}, {\"dev\": \"ipi4\", \"label\": \"ipi4\"}, {\"dev\": \"ipi5\", \"label\": \"ipi5\"}, {\"dev\": \"ipi6\", \"label\": \"ipi6\"}, {\"dev\": \"ipi_nobuf1\", \"label\": \"ipi_nobuf1\"}, {\"dev\": \"ipi_nobuf2\", \"label\": \"ipi_nobuf2\"}, {\"dev\": \"ipi_nobuf3\", \"label\": \"ipi_nobuf3\"}, {\"dev\": \"ipi_nobuf4\", \"label\": \"ipi_nobuf4\"}, {\"dev\": \"ipi_nobuf5\", \"label\": \"ipi_nobuf5\"}, {\"dev\": \"ipi_nobuf6\", \"label\": \"ipi_nobuf6\"}, {\"dev\": \"ipi_asu\", \"label\": \"ipi_asu\"}, {\"dev\": \"ipi_pmc\", \"label\": \"ipi_pmc\"}, {\"dev\": \"ipi_pmc_nobuf\", \"label\": \"ipi_pmc_nobuf\"}, {\"dev\": \"ps_wizard_0_ps11_0_ipi_buffer\", \"label\": \"ps_wizard_0_ps11_0_ipi_buffer\"}, {\"dev\": \"cpu_opp_table\", \"label\": \"cpu_opp_table\"}, {\"dev\": \"fpga\", \"label\": \"fpga\"}, {\"dev\": \"timer\", \"label\": \"timer\"}, {\"dev\": \"versal_fpga\", \"label\": \"versal_fpga\"}, {\"dev\": \"amba_rpu\", \"label\": \"amba_rpu\"}, {\"dev\": \"sensor0\", \"label\": \"sensor0\"}, {\"dev\": \"scmi_buf\", \"label\": \"scmi_buf\"}, {\"dev\": \"zynqmp-ipi\"}, {\"dev\": \"pwm-fan\"}, {\"dev\": \"usb_hub_delay\", \"label\": \"usb_hub_delay\"}, {\"dev\": \"__lopper-phandles__\"}, {\"dev\": \"iommu@ec000000\"}, {\"dev\": \"mmi-usb\"}, {\"dev\": \"mmi_gpu_slcr@ed720000\"}, {\"dev\": \"physical-memory-group-manager\"}, {\"dev\": \"timer@f1e90000\"}, {\"dev\": \"mailbox@eb360000\"}, {\"dev\": \"libmetal_uio_desc0@99c8000\"}, {\"dev\": \"libmetal_uio_desc1@99cc000\"}, {\"dev\": \"libmetal_uio_data@99d0000\"}]";
                        lopper,memory-keep-all = <0x1>;

                        domain-to-domain {
                                compatible = "openamp,domain-to-domain-v1";

                                remoteproc-relation {
                                        compatible = "openamp,remoteproc-v2";

                                        relation0 {
                                                remote = <0x204>;
                                                elfload = <&ddrboot>,
                                                 <&trace_buffer>,
                                                 <&rsctbl>;
                                        };
                                };

                                rpmsg-relation {
                                        compatible = "openamp,rpmsg-v1";

                                        relation0 {
                                                remote = <0x204>;
                                                carveouts = <0x1fe 0x1ff 0x200>;
                                                mbox = <0x1aa>;
                                        };
                                };

                                libmetal-relation {
                                        compatible = "libmetal,ipc-v1";

                                        relation0 {
                                                remote = <0x205>;
                                                carveouts = <0x1f6 0x1f7 0x1f8>;
                                                mbox = <0x179>;
                                                timer = <0x9f>;
                                        };
                                };
                        };
                };

                RPU_Zephyr {
                        phandle = <0x204>;
                        compatible = "openamp,domain-v1";
                        lopper,activate = "zephyr";
                        os,type = "zephyr";
                        zephyr-version = "4.3";
                        xlnx,ddr-boot;
                        xlnx,zephyr,mems = "ddrboot@9800100";
                        sram = <0x0 0x9800100 0x0 0x5de00 0x0 0xeba00000 0x0 0x10000 0x0 0xeba10000 0x0 0x8000 0x0 0xeba20000 0x0 0x8000>;
                        reserved-memory = <0x201 0x202 0x203>;
                        access = <&serial0 0x0>;
                        rpu_pd_val = <0xb9 0x0>;
                        cpu_config_str = "split";
                        core_num = <0x0>;
                        linker_file_output_name = "openamp-zephyr.ld";
                        linker-entry = "_vector_table";
                        linker_memories = <0x21 0x22 0x23 0x201 0x203>;
                        linker-section-vector-table = <0x21>;
                        linker-section-vector-table-offset = <0x0>;
                        linker-section-text = <0x21>;
                        linker-section-rodata = <0x21>;
                        linker-section-data = <0x22>;
                        linker-section-bss = <0x22>;
                        linker-section-noinit = <0x22>;
                        linker-section-heap = <0x22>;
                        linker-section-stack = <0x22>;
                        linker-section-resource-table = <0x203>;
                        linker-section-resource-table-offset = <0x0>;
                        access-json = "[{\"dev\": \"serial@f1920000\"}, {\"dev\": \"timer@f1e80000\"}, {\"dev\": \"mailbox@eb340000\"}, {\"dev\": \"mailbox@eb3b1000\"}, {\"dev\": \"r52_0a_atcm_global@eba00000\"}, {\"dev\": \"r52_0a_btcm_global@eba10000\"}, {\"dev\": \"r52_0a_ctcm_global@eba20000\"}]";

                        domain-to-domain {
                                compatible = "openamp,domain-to-domain-v1";

                                rpmsg-relation {
                                        compatible = "openamp,rpmsg-v1";

                                        relation0 {
                                                host = <0x206>;
                                                mbox = <0x1b4>;
                                                carveouts = <0x1fe 0x1ff 0x200>;
                                        };
                                };
                        };
                };

                RPU_1_BM {
                        phandle = <0x205>;
                        compatible = "openamp,domain-v1";
                        sram = <0x0 0x9968000 0x0 0x60000 0x0 0xeba40000 0x0 0x10000 0x0 0xeba50000 0x0 0x8000 0x0 0xeba60000 0x0 0x8000>;
                        memory = <0x0 0x9968000 0x0 0x60000>;
                        access = <&serial0 0x0>,
                         <&i2c0 0x0>,
                         <&ttc3 0x0>,
                         <&ipi2 0x0>,
                         <&libmetal_uio_desc099c8000 0x0>,
                         <&libmetal_uio_desc199cc000 0x0>,
                         <&libmetal_uio_data99d0000 0x0>,
                         <&libmetal_desc0 0x0>,
                         <&libmetal_desc1 0x0>,
                         <&libmetal_data 0x0>;
                        cpus = <&cpus_r52_1 0x1 0x80000003>;
                        os,type = "baremetal";
                        rpu_pd_val = <0xb9 0x1>;
                        cpu_config_str = "split";
                        core_num = <0x0>;
                        access-json = "[{\"dev\": \"serial@f1920000\"}, {\"dev\": \"i2c@f1940000\"}, {\"dev\": \"timer@f1e90000\"}, {\"dev\": \"mailbox@eb350000\"}, {\"dev\": \"libmetal_uio_desc0@99c8000\"}, {\"dev\": \"libmetal_uio_desc1@99cc000\"}, {\"dev\": \"libmetal_uio_data@99d0000\"}, {\"dev\": \"libmetal_desc0@99c8000\"}, {\"dev\": \"libmetal_desc1@99cc000\"}, {\"dev\": \"libmetal_data@99d0000\"}]";

                        domain-to-domain {
                                compatible = "openamp,domain-to-domain-v1";

                                libmetal-relation {
                                        compatible = "libmetal,ipc-v1";

                                        relation0 {
                                                host = <0x206>;
                                                carveouts = <0x1f6 0x1f7 0x1f8>;
                                                mbox = <0x16f>;
                                                timer = <0x9f>;
                                                elfload = <&libmetal_elf>;
                                        };
                                };
                        };
                };
        };
};
