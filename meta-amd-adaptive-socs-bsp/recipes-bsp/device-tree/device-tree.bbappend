FILESEXTRAPATHS:prepend:versal-vek280-sdt-seg:linux := "${THISDIR}/files:"
EXTRA_DT_INCLUDE_FILES:append:versal-vek280-sdt-seg:linux = " versal-vek280-sdt-seg-system-conf.dtsi"

FILESEXTRAPATHS:prepend:versal-2ve-2vm-vek385-sdt-seg:linux := "${THISDIR}/files:"
EXTRA_DT_INCLUDE_FILES:append:versal-2ve-2vm-vek385-sdt-seg:linux = " versal-2ve-2vm-vek385-sdt-seg-system-conf.dtsi"

