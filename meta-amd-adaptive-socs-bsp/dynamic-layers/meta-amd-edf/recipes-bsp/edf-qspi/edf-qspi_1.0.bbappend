COMPATIBLE_MACHINE:versal-vck190-sdt-seg = "${MACHINE}"
