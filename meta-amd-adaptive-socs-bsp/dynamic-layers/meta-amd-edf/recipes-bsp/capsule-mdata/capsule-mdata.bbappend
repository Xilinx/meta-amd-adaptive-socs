COMPATIBLE_MACHINE:versal-vek280-sdt-seg = "${MACHINE}"
COMPATIBLE_MACHINE:versal-2ve-2vm-vek385-sdt-seg = "${MACHINE}"

IMAGE_TYPE_GUID_0:versal-vek280-sdt-seg = "c9d8f01a-a7b3-094e-9f25-7c9823b8a6f2"
IMAGE_TYPE_GUID_0:versal-2ve-2vm-vek385-sdt-seg = "4de527cb-3a8f-774c-8a72-1c76d2d4e938"
