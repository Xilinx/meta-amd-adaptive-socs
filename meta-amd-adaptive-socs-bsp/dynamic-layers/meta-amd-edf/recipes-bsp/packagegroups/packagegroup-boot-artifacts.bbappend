# EDF_DEPLOY_DEPENDS is specified in meta-amd-edf

DEPLOY_DEPENDS:append:versal-vrk160-sdt-seg = " ${EDF_DEPLOY_DEPENDS}"
DEPLOY_DEPENDS:append:versal-vek280-sdt-seg = " ${EDF_DEPLOY_DEPENDS}"
DEPLOY_DEPENDS:append:versal-2ve-2vm-vek385-sdt-seg = " ${EDF_DEPLOY_DEPENDS}"
DEPLOY_DEPENDS:append:versal-2ve-2vm-vek385-revb-sdt-seg = " ${EDF_DEPLOY_DEPENDS}"
DEPLOY_DEPENDS:append:versal-vrk165-sdt-seg = " ${EDF_DEPLOY_DEPENDS}"
