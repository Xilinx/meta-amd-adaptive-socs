FILESEXTRAPATHS:prepend:versal-vek280-sdt-seg := "${THISDIR}/versal-vek280-sdt-seg:"
FILESEXTRAPATHS:prepend:versal-2ve-2vm-vek385-sdt-seg := "${THISDIR}/versal-2ve-2vm-vek385-sdt-seg:"
