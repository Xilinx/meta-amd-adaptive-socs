COMPATIBLE_MACHINE:versal-vek280-sdt-seg = "${MACHINE}"

UEFI_CAB_GUID:versal-vek280-sdt-seg = "c9d8f01a-a7b3-094e-9f25-7c9823b8a6f2"
