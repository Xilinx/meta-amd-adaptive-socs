FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-xlnx-imgrcvry:"

PREBOOT_CFG_FILE:versal-2ve-2vm-vmk365-multidomain ?= "file://preboot_cmd_versal_2ve_2vm_vmk365.cfg"
